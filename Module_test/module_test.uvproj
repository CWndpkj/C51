# Keil uVision project module_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: module_test +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: delay.c delay.h LCD1602.c LCD1602.h main.c IRC_Test.c IRC_Test.h
    ../common/: 8bit_SMG.c 8bit_SMG.h
