# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 8bit_SMG.h 8bit_SMG.c delay.c delay.h matrixkey.c matrixkey.h
    ../../LCD1602驱动代码/: LCD1602.c LCD1602.h
